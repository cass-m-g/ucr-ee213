* Test netlist 3 -- RC circuit

R1 1 2 1000
C1 2 0 0.0001
Vs 1 0 15
