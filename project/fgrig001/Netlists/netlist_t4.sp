* Test netlist 4 -- RL circuit

R1 1 2 1000
L1 2 0 0.0001
Vs 1 0 15
